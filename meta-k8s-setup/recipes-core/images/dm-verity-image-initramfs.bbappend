core-image-minimal-initramfs.bbappend