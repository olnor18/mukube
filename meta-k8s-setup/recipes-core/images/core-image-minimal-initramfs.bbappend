PACKAGE_INSTALL += "initramfs-module-ramrootfs"
